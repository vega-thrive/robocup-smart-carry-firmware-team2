# Keil uVision project BanyunCommonF407.uvprojx, settings and files
target BanyunCommonF407 (6240000::V6.24::ARMCLANG)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: BanyunCommonF407 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../BSP
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Inc/: main.h can.h dma.h fsmc.h gpio.h stm32f4xx_hal_conf.h stm32f4xx_it.h tim.h usart.h
    ../Core/Src/: main.c gpio.c can.c dma.c fsmc.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_nor.c stm32f4xx_hal_sram.c stm32f4xx_hal_nand.c stm32f4xx_hal_pccard.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group BSP
    ../BSP/: LCD.c LCD.h LCD_FONT.h PID.c PID.h Sensor.c Sensor.h LineFollow.c LineFollow.h LCD_FONT.c Moto.c ChassisMotor.c ChassisMotor.h HWT101.c HWT101.h GM65Scanner.c GM65Scanner.h CompetitionQr.c CompetitionQr.h QrMissionMap.c QrMissionMap.h MaxiCam.c MaxiCam.h VisionAlignment.c VisionAlignment.h Servo4.c Servo4.h ProjectService.c ProjectService.h TrapMove.c TrapMove.h CompetitionTask.c CompetitionTask.h ChassisPos.c ChassisPos.h HeadingHold.c HeadingHold.h Task1Color.c Task1Color.h TurntableInventory.c TurntableInventory.h VofaTune.c VofaTune.h
software components: CMSIS:CORE 5.6.0
